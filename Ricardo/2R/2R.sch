** sch_path: Ricardo/2R/2R.sch
**.subckt 2R TE BE
*.iopin TE
*.iopin BE
XR1 TE BE rram_v0
XR2 TE BE rram_v0
**.ends
.end
